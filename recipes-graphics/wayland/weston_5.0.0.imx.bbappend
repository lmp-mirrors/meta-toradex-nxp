FILESEXTRAPATHS_prepend := "${THISDIR}/weston:"
SRC_URI += "file://weston.ini"
SRCREV = "73a26456e43b6d4f72f0a995d437590065cafb15"

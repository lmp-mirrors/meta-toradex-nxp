# update to 1.6.0
PV = "1.6.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=6dfb32a488e5fd6bae52fbf6c7ebb086"
SRC_URI[md5sum] = "080de224085c37db107b5e477bd7900a"
SRC_URI[sha256sum] = "854014164be517467252a2f0a79145bdcdd2892243b317ba25a3157d85a612ba"

SRCREV = "49cca25f6319f3607b121093e46e474fe528aa39"
RDEPENDS_${PN}_append_imxgpu = " ${PN}-etnaviv ${PN}-vivante"

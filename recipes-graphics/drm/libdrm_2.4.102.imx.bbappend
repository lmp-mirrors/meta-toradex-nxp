RDEPENDS_${PN}_append_imxgpu_tdx = " ${PN}-etnaviv ${PN}-vivante"

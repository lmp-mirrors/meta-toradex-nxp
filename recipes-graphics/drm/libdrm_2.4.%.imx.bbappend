RRECOMMENDS:${PN}:append:imxgpu = " ${PN}-vivante"

FILESEXTRAPATHS_prepend := "${THISDIR}/xserver-xorg:"

SRC_URI_append = " file://0001-modesetting-Fix-16-bit-depth-bpp-mode.patch"

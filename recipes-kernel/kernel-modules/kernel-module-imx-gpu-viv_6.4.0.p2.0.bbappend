PV = "6.4.0.p2.4"
LOCALVERSION = "-${SRCBRANCH}"
SRCBRANCH = "toradex_5.4-2.1.x-imx"
KERNEL_SRC = "git://git.toradex.com/linux-toradex.git;protocol=git"
# Keep that one stable, i.e. use the exact git hash from the NXP BSP.
SRCREV = "2f6f3e92a82e51fe39b53ee758273bef26964836"

PV = "6.2.4.p4.0"
LOCALVERSION = "-${SRCBRANCH}"
SRCBRANCH = "imx_4.14.98_2.0.0_ga"
SRCREV = "f54dc1486d13d44766cdb6551d094313f077b535"
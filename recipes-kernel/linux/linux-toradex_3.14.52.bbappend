FILESEXTRAPATHS_prepend := "${THISDIR}/linux-toradex-3.14.52:"

LOCALVERSION = "-v2.6.1b1"
SRCREV = "3c522150e4230f36684f4c976abf755db990f0c2"
SRCBRANCH = "toradex_imx_3.14.52_1.1.0_ga-next"

LIC_FILES_CHKSUM:tdx = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
SRCBRANCH:tdx = "toradex_5.15-2.0.x-imx"
SRC_URI:tdx = "git://git.toradex.com/linux-toradex.git;protocol=https;branch=${SRCBRANCH}"
# Keep that one stable, i.e. use the exact git hash from the NXP BSP.
SRCREV:tdx = "fa6c3168595c02bd9d5366fcc28c9e7304947a3d"

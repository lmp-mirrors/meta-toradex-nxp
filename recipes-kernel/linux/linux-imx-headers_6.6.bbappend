LIC_FILES_CHKSUM:tdx = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
SRCBRANCH:tdx = "toradex_6.6-2.0.x-imx"
SRC_URI:tdx = "git://git.toradex.com/linux-toradex.git;protocol=https;branch=${SRCBRANCH}"
# Keep that one stable, i.e. use the exact git hash from the NXP BSP.
SRCREV:tdx = "a9adc0280d6e8fde5718caf259e89692ba67a9ea"

LOCALVERSION = "-v2.6b1"
SRCBRANCH = "toradex_imx_3.14.28_1.0.0_ga"
SRCREV = "0bb38d19090dc611c8bc9c18e770620c73f7563c"

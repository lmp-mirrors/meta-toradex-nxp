FILESEXTRAPATHS_prepend := "${THISDIR}/linux-toradex-4.1.15:"

LOCALVERSION = "-v2.6.2b1"
SRCREV = "08e1fa5fbfc087f6ecdb7920e049e889a51c52ac"
SRCBRANCH = "toradex_imx_4.1.15_1.0.0_ga-next"

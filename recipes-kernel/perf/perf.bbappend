# perf with a 4.4 kernel no longer compiles
COMPATIBLE_MACHINE_use-nxp-bsp_colibri-vf = "(^$)"

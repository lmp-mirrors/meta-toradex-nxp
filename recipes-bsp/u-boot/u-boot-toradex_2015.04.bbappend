PV = "v2015.04-v2.6b1+git${SRCPV}"

SRCREV = "e1a48b27907ae3f4592de43d42939a654aed9533"
SRCBRANCH = "2015.04-toradex-next"

COMPATIBLE_MACHINE = "(mx6|mx7|vf)"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0001-tools-image-host-fix-wrong-return-value.patch \
"

IMX_SYSTEM_MANAGER_SRC:tdx = "git://gitlab.int.toradex.com/rd/linux-bsp/imx-sm-toradex.git;protocol=https"
SRCBRANCH:tdx = "main"
SRCREV:tdx = "6c8724cd53b19508132acadd8c0e099e5f4039f9"

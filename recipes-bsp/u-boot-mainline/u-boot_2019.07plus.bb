require u-boot-common.inc
require u-boot.inc
require recipes-bsp/u-boot/u-boot-toradex-initial-env.inc

DEPENDS += "bc-native dtc-native"

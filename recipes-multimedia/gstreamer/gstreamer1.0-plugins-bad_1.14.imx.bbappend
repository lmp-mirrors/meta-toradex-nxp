SRCBRANCH = "MM_04.04.05_1902_L4.14.98_GA"
SRCREV = "0191521ba226904e4b2f84c38e5f6ae75169a18a"
SRC_URI_remove ="file://0001-opencv-fix-build-for-opencv-3-4-2.patch"
SRCBRANCH = "MM_04.05.05_2005_L5.4.24"
SRCREV = "fc6d8ccf3bd775517fafb1ce1d9224312d2812d8"
